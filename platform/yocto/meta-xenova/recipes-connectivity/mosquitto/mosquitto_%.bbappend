# 개발용 의존성만 미리 설치한다. 계정/ACL/리스너를 확정한 담당자가 활성화한다.
SYSTEMD_AUTO_ENABLE:${PN} = "disable"
